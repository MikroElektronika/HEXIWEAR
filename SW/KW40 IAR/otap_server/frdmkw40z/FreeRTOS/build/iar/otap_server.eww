<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
<batchBuild><batchDefinition><name>all</name><member><project>ksdk_freertos_lib</project><configuration>Debug</configuration></member><member><project>ksdk_freertos_lib</project><configuration>Release</configuration></member><member><project>otap_server</project><configuration>Debug</configuration></member><member><project>otap_server</project><configuration>Release</configuration></member></batchDefinition><batchDefinition><name>Debug</name><member><project>ksdk_freertos_lib</project><configuration>Debug</configuration></member><member><project>otap_server</project><configuration>Debug</configuration></member></batchDefinition><batchDefinition><name>Release</name><member><project>ksdk_freertos_lib</project><configuration>Release</configuration></member><member><project>otap_server</project><configuration>Release</configuration></member></batchDefinition></batchBuild>
<project><path>$_KSDK13_FWK524_PATH_$\lib\ksdk_freertos_lib\iar\KW40Z4\ksdk_freertos_lib.ewp</path></project><project><path>$WS_DIR$/otap_server.ewp</path></project></workspace>
