# IAR project OtapBootloader.ewp, settings and files
configuration BootloaderOTAP_KW24D512 (ARM, debug)
  General.OGChipSelectEditMenu: MK21DN512xxx5 Freescale MK21DN512xxx5
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: MCU_MK21DN512; gEepromType_d=gEepromDevice_AT45DB161E_c
  ICCARM.CCDiagSuppress: Pa039
  ICCARM.CCIncludePath2: src\OtapSerialBootloader; src\eeprom; src\spi; src\flash; src\include; src\; src\include\cfg; 
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: OtapBootloader.bin
  postbuild: $TOOLKIT_DIR$\bin\ielftool "BootloaderOTAP_KW24D512\exe\BootloaderOTAP_KW24D512.out" "Binaries\BootloaderOTAP_KW24D512.bin" --bin --silent
  ILINK.IlinkOutputFile: BootloaderOTAP_KW24D512.out
  ILINK.IlinkConfigDefines: gRomSize_c=0x80000
  ILINK.IlinkIcfFile: Linker_cfg\BootloaderOTAP.icf
  ILINK.IlinkProgramEntryLabel: main
configuration BootloaderOTAP_KW21D256 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK21DX256xxx5 Freescale MK21DX256xxx5
  ICCARM.CCDefines: MCU_MK21DX256; gEepromType_d=gEepromDevice_AT45DB161E_c
  ICCARM.CCIncludePath2: src\OtapSerialBootloader; src\eeprom; src\spi; src\flash; src\include; src\; ; src\include\cfg
  postbuild: $TOOLKIT_DIR$\bin\ielftool "BootloaderOTAP_KW21D256\exe\BootloaderOTAP_KW21D256.out" "Binaries\BootloaderOTAP_KW21D256.bin" --bin --silent
  ILINK.IlinkOutputFile: BootloaderOTAP_KW21D256.out
  ILINK.IlinkConfigDefines: gRomSize_c=0x40000
configuration BootloaderOTAP_Serial_KW24D512 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: MCU_MK21DN512; gEepromType_d=gEepromDevice_AT45DB161E_c; gSerialBootloaderEnable_c=1
  postbuild: $TOOLKIT_DIR$\bin\ielftool "BootloaderOTAP_Serial_KW24D512\exe\BootloaderOTAP_Serial_KW24D512.out" "Binaries\BootloaderOTAP_Serial_KW24D512.bin" --bin --silent
  ILINK.IlinkOutputFile: BootloaderOTAP_Serial_KW24D512.out
configuration BootloaderOTAP_KL46Z256 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MKL46Z256xxx4 Freescale MKL46Z256xxx4
  General.CoreVariant: 35
  ICCARM.CCDefines: MCU_MKL46Z256; gEepromType_d=gEepromDevice_InternalFlash_c
  ICCARM.CCIncludePath2: src\OtapSerialBootloader; src\spi; src\eeprom; src\flash; src\include; src\; ; src\include\cfg
  postbuild: $TOOLKIT_DIR$\bin\ielftool "BootloaderOTAP_KL46Z256\exe\BootloaderOTAP_KL46Z256.out" "Binaries\BootloaderOTAP_KL46Z256.bin" --bin --silent
  ILINK.IlinkOutputFile: BootloaderOTAP_KL46Z256.out
  ILINK.IlinkConfigDefines: gRomSize_c=0x40000
configuration BootloaderOTAP_KW40Z4 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MKL46Z256xxx4 Freescale MKL46Z256xxx4
  General.CoreVariant: 35
  ICCARM.CCDefines: MCU_MKW40Z160; gEepromType_d=gEepromDevice_M25P80_c
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: BootloaderOTAP_KW40Z4.bin
  postbuild: $TOOLKIT_DIR$\bin\ielftool "BootloaderOTAP_KW40Z4\exe\BootloaderOTAP_KW40Z4.out" "Binaries\BootloaderOTAP_KW40Z4.bin" --bin --silent
  ILINK.IlinkOutputFile: BootloaderOTAP_KW40Z4.out
  ILINK.IlinkConfigDefines: gRomSize_c=0x28000
configuration BootloaderOTAP_K64FN1M (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: MCU_MK64FN1M; gEepromType_d=gEepromDevice_InternalFlash_c; gEepromParams_WriteAlignment_c=8
  postbuild: $TOOLKIT_DIR$\bin\ielftool "BootloaderOTAP_K64FN1M\exe\BootloaderOTAP_K64FN1M.out" "Binaries\BootloaderOTAP_K64FN1M.bin" --bin --silent
  ILINK.IlinkOutputFile: BootloaderOTAP_K64FN1M.out
  ILINK.IlinkConfigDefines: gRomSize_c=0x100000
  group eeprom
    src/eeprom/: Eeprom_Boot.h Eeprom_Boot_AT26DF081A.c Eeprom_Boot_AT45DB021E.c Eeprom_Boot_AT45DB161E.c Eeprom_Boot_M25P80.c
  group flash
    src/flash/: flash_boot_kinetis.c flash_boot_kinetis.h
  group Include
    src/include/: EmbeddedTypes.h MK21D5.h MKL46Z4.h
  group Include/cfg
    src/include/cfg/: MK21D256_cfg.h MK21D512_cfg.h MK64F12_cfg.h MKL46Z256_cfg.h MKW40Z160_cfg.h
  group OtapBootloader
    src/OtapSerialBootloader/: OtapBootloader.c OtapBootloader.h UartBootloade.c UartBootloader.h
  group spi
    src/spi/: SPI.c SPI.h
