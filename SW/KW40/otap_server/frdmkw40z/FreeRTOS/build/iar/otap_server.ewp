# IAR project otap_server.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKW40Z160xxx4 Freescale MKW40Z160xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG; IAR; CPU_MKW40Z160VHT4
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050
  ICCARM.PreInclude: ../../app_preinclude.h
  ICCARM.CCIncludePath2: $_KSDK13_FWK524_PATH_$/platform/CMSIS/Include; ../../../../../../../boards/frdmkw40z; $_KSDK13_FWK524_PATH_$/platform/devices; $_KSDK13_FWK524_PATH_$/platform/devices/MKW40Z4/include; $_KSDK13_FWK524_PATH_$/platform/devices/MKW40Z4/startup; $_KSDK13_FWK524_PATH_$/platform/system/src/clock/MKW40Z4; $_KSDK13_FWK524_PATH_$/platform/devices; $_KSDK13_FWK524_PATH_$/platform/devices/MKW40Z4/startup; $_KSDK13_FWK524_PATH_$/rtos/FreeRTOS/include; $_KSDK13_FWK524_PATH_$/rtos/FreeRTOS/port/iar; $_KSDK13_FWK524_PATH_$/rtos/FreeRTOS/config/KW40Z4/iar; ../../../../../../../framework/Flash/External/Interface; ../../../../../../../framework/Flash/Internal; $_KSDK13_FWK524_PATH_$/platform/drivers/src/flash/C90TFS/drvsrc/include; ../../../../../../../framework/GPIOIrq; ../../../../../../../framework/Keyboard/Interface; ../../../../../../../framework/LED/Interface; ../../../../../../../framework/SerialManager/Source/SPI_Adapter; ../../../../../../../framework/Common; ../../../../../../../framework/FSCI/Interface; ../../../../../../../framework/FSCI/Source; ../../../../../../../framework/MemManager/Interface; ../../../../../../../framework/Messaging/Interface; ../../../../../../../framework/LowPower/Interface/MKW4xZ; ../../../../../../../framework/LowPower/Interface/MKW4xZ; ../../../../../../../framework/OSAbstraction/Interface; $_KSDK13_FWK524_PATH_$/platform/osa/inc; ../../../../../../../framework/OtaSupport/Interface; ../../../../../../../framework/Panic/Interface; ../../../../../../../framework/RNG/Interface; ../../../../../../../framework/SerialManager/Interface; ../../../../../../../framework/TimersManager/Interface; ../../../../../../../framework/TimersManager/Source; ../../../../../../../framework/FunctionLib; ../../../../../../../framework/Lists; ../../../../../../../framework/SecLib; ../../../../../../../framework/ModuleInfo; ../../../../../../../bluetooth/host/interface; ../../../../../common; ../../../../../common; ../../../../../../../bluetooth/controller/interface; ../../../../../common; ../../../../../../../bluetooth/hci_transport/interface; ../../../../../common/gatt_db; ../../../../../common/gatt_db/macros; ../../../../../../../bluetooth/profiles/battery; ../../../../../../../bluetooth/profiles/device_info; ../../../../../../../bluetooth/profiles/otap; ../../../../../../../framework/XCVR/MKW40Z4; ../../../../common; ../../../../../../../framework/DCDC/Interface; $_KSDK13_FWK524_PATH_$/platform/drivers/inc; $_KSDK13_FWK524_PATH_$/platform/system/inc; $_KSDK13_FWK524_PATH_$/platform/hal/inc; $_KSDK13_FWK524_PATH_$/platform/utilities/inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  AARM.AUserIncludes: $_KSDK13_FWK524_PATH_$\rtos\FreeRTOS\config\KW40Z4\iar
  OBJCOPY.OOCOutputFile: otap_server.bin
  ILINK.IlinkOutputFile: otap_server_FreeRTOS.out
  ILINK.IlinkConfigDefines: gUseNVMLink_d=1; __heap_size__=0; __stack_size__=1024; __ram_vector_table__=1
  ILINK.IlinkIcfFile: ../../../../../../../platform/devices/MKW40Z4/linker/iar/MKW40Z160xxx4_connectivity.icf
  ILINK.IlinkAdditionalLibs: ../../../../../../../bluetooth/host/lib/ble_host_central_lib.a; $_KSDK13_FWK524_PATH_$\lib\ksdk_freertos_lib\iar\KW40Z4\debug\libksdk_platform_freertos.a; ../../../../../../../framework/SecLib/lib_crypto_IAR_M0.a; ../../../../../../../bluetooth/controller/lib/ble_controller_lib.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; IAR; CPU_MKW40Z160VHT4
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  OBJCOPY.OOCOutputFile: generic.bin
  ILINK.IlinkAdditionalLibs: ../../../../../../../bluetooth/host/lib/ble_host_central_lib.a; $_KSDK13_FWK524_PATH_$\lib\ksdk_freertos_lib\iar\KW40Z4\release\libksdk_platform_freertos.a; ../../../../../../../framework/SecLib/lib_crypto_IAR_M0.a; ../../../../../../../bluetooth/controller/lib/ble_controller_lib.a
  group app/common
    ../../../../../common/: ApplMain.c ApplMain.h ble_controller_task.c ble_controller_task_config.h ble_host_task_config.h ble_host_tasks.c ble_init.c ble_init.h
  group app/common/gatt_db
    ../../../../../common/gatt_db/: gatt_database.c gatt_db_handles.h
  group app/common/gatt_db/macros
    ../../../../../common/gatt_db/macros/: gatt_alloc_x.def gatt_db_macros.h gatt_db_x_macros.def gatt_decl_x.def gatt_enum_x.def gatt_init_x.def gatt_size_x.def gatt_uuid_decl_x.def gatt_uuid_def_x.def
  group app/otap_server
    ../../../../common/: app.c app.h app_config.c fsci_ble_otap.c fsci_ble_otap.h gatt_db.h gatt_uuid128.h
    ../../: app_preinclude.h
  group bluetooth/controller/interface
    ../../../../../../../bluetooth/controller/interface/: controller_interface.h
  group bluetooth/hci_transport/interface
    ../../../../../../../bluetooth/hci_transport/interface/: hci_transport.h
  group bluetooth/hci_transport/source
    ../../../../../../../bluetooth/hci_transport/source/: hcit_serial_interface.c
  group bluetooth/host/interface
    ../../../../../../../bluetooth/host/interface/: att_errors.h ble_constants.h ble_general.h ble_host_tasks.h ble_sig_defines.h ble_utils.h gap_interface.h gap_types.h gatt_client_interface.h gatt_database.h gatt_db_app_interface.h gatt_interface.h gatt_server_interface.h gatt_types.h hci_interface.h hci_types.h l2ca_cb_interface.h l2ca_interface.h l2ca_types.h smp_packets.h smp_types.h vendor_debug_commands.h
  group bluetooth/host/source
    ../../../../../../../bluetooth/host/source/: ble_globals.c
  group bluetooth/profiles/battery
    ../../../../../../../bluetooth/profiles/battery/: battery_service.c
  group bluetooth/profiles/device_info
    ../../../../../../../bluetooth/profiles/device_info/: device_info_service.c
  group bluetooth/profiles/interface
    ../../../../../../../bluetooth/profiles/battery/: battery_interface.h
    ../../../../../../../bluetooth/profiles/device_info/: device_info_interface.h
    ../../../../../../../bluetooth/profiles/otap/: otap_interface.h
  group bluetooth/profiles/otap
    ../../../../../../../bluetooth/profiles/otap/: otap_service.c
  group framework/Common
    ../../../../../../../framework/Common/: EmbeddedTypes.h FwkInit.c
  group framework/DCDC/Interface
    ../../../../../../../framework/DCDC/Interface/: DCDC.h
  group framework/DCDC/Source
    ../../../../../../../framework/DCDC/Source/: DCDC.c
  group framework/Flash/External/Interface
    ../../../../../../../framework/Flash/External/Interface/: Eeprom.h
  group framework/Flash/External/Source
    ../../../../../../../framework/Flash/External/Source/: Eeprom_AT26DF081A.c Eeprom_AT45DB021E.c Eeprom_AT45DB161E.c Eeprom_InternalFlash.c
  group framework/Flash/Internal
    ../../../../../../../../KSDK_1.3.0/platform/drivers/src/flash/C90TFS/drvsrc/source/: CopyToRam.c DEFlashPartition.c DFlashGetProtection.c DFlashSetProtection.c EEEWrite.c EERAMGetProtection.c EERAMSetProtection.c FlashCheckSum.c FlashCommandSequence.c FlashEraseAllBlock.c FlashEraseResume.c FlashEraseSector.c FlashEraseSuspend.c FlashGetSecurityState.c FlashInit.c FlashProgram.c FlashProgramCheck.c FlashProgramOnce.c FlashProgramSection.c FlashReadOnce.c FlashReadResource.c FlashSecurityBypass.c FlashVerifyAllBlock.c FlashVerifyBlock.c FlashVerifySection.c PFlashGetProtection.c PFlashSetProtection.c PFlashSwap.c PFlashSwapCtl.c SetEEEEnable.c
    ../../../../../../../framework/Flash/Internal/: Flash_Adapter.c Flash_Adapter.h
    ../../../../../../../../KSDK_1.3.0/platform/drivers/src/flash/C90TFS/drvsrc/include/: FTFx_KX_flash_config.h SSD_FTFx.h SSD_FTFx_Common.h SSD_FTFx_Internal.h SSD_Types.h
  group framework/FSCI/Interface
    ../../../../../../../framework/FSCI/Interface/: FsciInterface.h
  group framework/FSCI/Source
    ../../../../../../../framework/FSCI/Source/: FsciCommands.c FsciCommands.h FsciCommunication.c FsciCommunication.h FsciLogging.c FsciMain.c
  group framework/FunctionLib
    ../../../../../../../framework/FunctionLib/: FunctionLib.c FunctionLib.h
  group framework/GPIOIrq/Interface
    ../../../../../../../framework/GPIOIrq/: GPIO_IrqAdapter.h
  group framework/GPIOIrq/Source
    ../../../../../../../framework/GPIOIrq/: GPIO_IrqAdapter.c
  group framework/Keyboard/Interface
    ../../../../../../../framework/Keyboard/Interface/: Keyboard.h
  group framework/Keyboard/Source
    ../../../../../../../framework/Keyboard/Source/: Keyboard.c
  group framework/LED/Interface
    ../../../../../../../framework/LED/Interface/: LED.h
  group framework/LED/Source
    ../../../../../../../framework/LED/Source/: LED.c
  group framework/Lists
    ../../../../../../../framework/Lists/: GenericList.c GenericList.h
  group framework/LowPower/Interface
    ../../../../../../../framework/LowPower/Interface/MKW4xZ/: PWR_Configuration.h PWR_Interface.h
  group framework/LowPower/Source
    ../../../../../../../framework/LowPower/Source/MKW4xZ/: PWR.c PWR_BLE.c PWR_BLE.h PWRLib.c PWRLib.h
  group framework/MemManager/Interface
    ../../../../../../../framework/MemManager/Interface/: MemManager.h
  group framework/MemManager/Source
    ../../../../../../../framework/MemManager/Source/: MemManager.c
  group framework/Messaging/Interface
    ../../../../../../../framework/Messaging/Interface/: Messaging.h
  group framework/Messaging/Source
    ../../../../../../../framework/Messaging/Source/: Messaging.c
  group framework/ModuleInfo
    ../../../../../../../framework/ModuleInfo/: ModuleInfo.h
  group framework/OSAbstraction/Interface
    ../../../../../../../framework/OSAbstraction/Interface/: fsl_osa_ext.h fsl_osa_ext_config.h
  group framework/OSAbstraction/Source
    ../../../../../../../framework/OSAbstraction/Source/: fsl_osa_ext_freertos.c
  group framework/OtaSupport/Interface
    ../../../../../../../framework/OtaSupport/Interface/: OtaSupport.h
  group framework/OtaSupport/Source
    ../../../../../../../framework/OtaSupport/Source/: OtaSupport.c
  group framework/Panic/Interface
    ../../../../../../../framework/Panic/Interface/: Panic.h
  group framework/Panic/Source
    ../../../../../../../framework/Panic/Source/: Panic.c
  group framework/Reset/Source
    ../../../../../../../framework/Reset/: Reset.c
  group framework/RNG/Interface
    ../../../../../../../framework/RNG/Interface/: RNG_Interface.h
  group framework/RNG/Source
    ../../../../../../../framework/RNG/Source/: RNG.c
  group framework/SecLib
    ../../../../../../../framework/SecLib/: SecLib.c SecLib.h
  group framework/SerialManager/Interface
    ../../../../../../../framework/SerialManager/Interface/: SerialManager.h
  group framework/SerialManager/Source
    ../../../../../../../framework/SerialManager/Source/: SerialManager.c
  group framework/SerialManager/Source/SPI_Adapter
    ../../../../../../../framework/SerialManager/Source/SPI_Adapter/: SPI_Adapter.c SPI_Adapter.h
  group framework/TimersManager/Interface
    ../../../../../../../framework/TimersManager/Interface/: TimersManager.h
  group framework/TimersManager/Source
    ../../../../../../../framework/TimersManager/Source/: TimersManager.c TimersManagerInternal.h TMR_Adapter.c TMR_Adapter.h
  group framework/XCVR/MKW40Z4
    ../../../../../../../framework/XCVR/MKW40Z4/: BLEDefaults.h ifr_mkw40z4_radio.c ifr_mkw40z4_radio.h ifr_tbl_apache_radio.h KW4xXcvrDrv.c KW4xXcvrDrv.h overwrites.h tsm_ll_timing.c tsm_ll_timing.h tsm_timing_ble.h tsm_timing_zigbee.h ZigbeeDefaults.h
  group KSDK
    ../../../../../../../boards/frdmkw40z/: board.c board.h gpio_pins.c gpio_pins.h hardware_init.c pin_mux.c pin_mux.h
  group RTOS/FreeRTOS
    ../../../../../../../../KSDK_1.3.0/rtos/FreeRTOS/src/: croutine.c event_groups.c heap_1.c heap_2.c heap_3.c heap_4.c list.c queue.c tasks.c timers.c
    ../../../../../../../../KSDK_1.3.0/rtos/FreeRTOS/include/: croutine.h event_groups.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
    ../../../../../../../../KSDK_1.3.0/rtos/FreeRTOS/config/KW40Z4/iar/: FreeRTOSConfig.h
    ../../../../../../../../KSDK_1.3.0/rtos/FreeRTOS/port/iar/: port.c portasm.s portmacro.h portTicks.h
  group RTOS/FreeRTOS/Startup
    ../../../../../../../../KSDK_1.3.0/platform/devices/: startup.c startup.h
    ../../../../../../../../KSDK_1.3.0/platform/devices/MKW40Z4/startup/iar/: startup_MKW40Z4.s
    ../../../../../../../../KSDK_1.3.0/platform/devices/MKW40Z4/startup/: system_MKW40Z4.c system_MKW40Z4.h
